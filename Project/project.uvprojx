# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\User\uC-CPU;..\User\uC-LIB;..\Project;..\User\uCOS-III\uCos-IIIPorts;..\User\uCOS-III\uCos-IIISource;..\Module
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\project.sct
  group User
    ./: main.c
  group uCos-III Source
    ../User/uCOS-III/uCos-IIISource/: os_core.c os_task.c os_var.c os_time.c os_cfg_app.c os_prio.c os_tick.c os_tmr.c os_sem.c os_mutex.c os_flag.c
  group uCos-III Ports
    ../User/uCOS-III/uCos-IIIPorts/: os_cpu_a.asm os_cpu.c
  group uC-CPU
    ../User/uC-CPU/: cpu_core.c
  group uC-LIB
    ../User/uC-LIB/: heap.c lib_std.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
